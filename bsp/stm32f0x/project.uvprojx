# Keil uVision project project.uvprojx, settings and files
target rt-thread (ARM-ADS)
  device: STM32F072CB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: template +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=2 OneElfS=1
  c define: USE_STDPERIPH_DRIVER
  c include: .;..\..\components\CMSIS\Include;..\..\components\drivers\include;..\..\components\finsh;..\..\components\init;..\..\include;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m0;Libraries\CMSIS\Include;Libraries\CMSIS\ST\STM32F0xx\Include;Libraries\STM32F0xx_StdPeriph_Driver\inc;applications;drivers;alatechLibraries
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --keep __fsym_*   --keep __rt_init*
  group Applications
    applications/: application.c startup.c
    ./applications/: cpuusage.c sport_timer.c sleeping.c
  group Drivers
    drivers/: board.c stm32f0xx_it.c
    ./drivers/: led.c usart.c scan_key_led.c scan_key_led.h i2c.c 24LCxx.c bz.c Incline.c heart.c pwm_vms.c ht1650.c ht1621.c Display.c
  group STM32_StdPeriph
    ./Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
    ./Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f0xx.s
    ./Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_dbgmcu.c stm32f0xx_gpio.c stm32f0xx_iwdg.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c stm32f0xx_misc.c
  group Kernel
    ../../src/: clock.c idle.c ipc.c irq.c kservice.c object.c scheduler.c thread.c timer.c device.c mem.c mempool.c
  group CORTEX-M0
    ../../libcpu/arm/cortex-m0/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c ringbuffer.c
  group finsh
    ../../components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c shell.c symbol.c
  group Components
    ../../components/init/: components.c
  group alatecLibraries
    ./alatechLibraries/: number_process.c 24lcxx_user.c 24lcxx_user.h matrix_process.c matrix_process.h ui_display_process.c seven_tab.c table_data.c
    ./drivers/: chandler.h
  group UiMode
    ./uiMode/: sysUiStart.c setProfiles.c key_libraries.c eepromErrMode.c sysSleep.c
  group Profile
    ./uiMode/: setProfileChoose.c setProfileRollingHill.c setProfilePeak.c setProfilePlateau.c setProfileClimb.c setProfileInterval_1.c setProfileInterval_2.c profileSport.c
  group Engineering
    ./uiMode/: eng_1.c EngineeringMode.c setKeyTest.c setLcdTest.c setBzTest.c setUint.c
  group User
    ./uiMode/: setUsers.c setUsersData.c setUsersNoData.c setUsersSport.c
  group Foucs
    ./uiMode/: setProfilesFocus.c setProfilesFocusData.c FocusSport.c
  group HeartRate
    ./uiMode/: setProfilesHeartRate.c setHeartRateTarget.c setHeartRateCardio.c setHeartRateFatBurn.c setProfilesHeartRateSport.c
  group Menual
    ./uiMode/: setProfileManual.c manualSport.c
  group Noramal
    ./uiMode/: setNoramal.c sportNoramal.c
